IMAGE_INSTALL_append += "coreutils"
IMAGE_INSTALL_append += "util-linux"
IMAGE_INSTALL_append += "u-boot-fw-utils"
IMAGE_INSTALL_append += "openalpr"
IMAGE_INSTALL_append += "python-openalpr"

# Mender
# require recipes-core/images/neutis-mender-image.inc

