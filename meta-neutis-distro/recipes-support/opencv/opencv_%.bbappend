PACKAGECONFIG_remove = "python3"
PACKAGECONFIG_append = "python2"
